# Keil uVision project project.uvproj, settings and files
target Flash (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  AfterMake: fromelf.exe --bin -o ./Flash/Obj/output.bin  ./Flash/Obj/output.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\User\bsp;..\..\User;..\..\Libraries\CMSIS\Include;..\..\RTX\inc;..\..\RTX\portable;..\..\User\CpuFlash;..\..\User\CRC8_16;..\..\User\DS1302;..\..\User\DWT;..\..\User\IIC;..\..\User\IWDG;..\..\User\Key;..\..\User\Led;..\..\User\Net;..\..\User\Protocal;..\..\User\Reader;..\..\User\SPI;..\..\User\Timer;..\..\User\Uart;..\..\User\Param
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../../User/: main.c RTX_Conf_CM.c main.h
  group BSP
    ../../User/bsp/: bsp.c bsp.h stm32f10x_it.c stm32f10x_assert.c stm32f10x_conf.h stm32f10x_it.h system_stm32f10x.c system_stm32f10x.h
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_tim.c stm32f10x_iwdg.c stm32f10x_spi.c
  group RTX/Source
    ../../RTX/src/: rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
  group RTX/Ports
    ../../RTX/portable/: HAL_CM3.c rt_HAL_CM.h SVC_Table.s
  group Doc
    ../../Doc/: 1.门禁命令协议.txt 2.readMe.txt
  group Wiegand
    ../../User/Reader/: Wiegand.c Wiegand.h
  group IIC
    ../../User/IIC/: bsp_eeprom_24xx.c bsp_eeprom_24xx.h bsp_i2c_gpio.c bsp_i2c_gpio.h
  group SPI
    ../../User/SPI/: bsp_spi_bus.c bsp_spi_bus.h bsp_spi_flash.c bsp_spi_flash.h
  group Key
    ../../User/Key/: key.c key.h
  group Net
    ../../User/Net/: device.c device.h socket.c socket.h spi2.c spi2.h types.h w5500.c w5500.h
  group DS1302
    ../../User/DS1302/: ds1302.c ds1302.h
  group CRC8_16
    ../../User/CRC8_16/: CRC8_16.c CRC8_16.h
  group Led
    ../../User/Led/: bsp_led.c bsp_led.h
  group Protocal
    ../../User/Protocal/: protocal.c protocal.h
  group Timer
    ../../User/Timer/: bsp_timer.c bsp_timer.h
  group CpuFlash
    ../../User/CpuFlash/: bsp_cpu_flash.c bsp_cpu_flash.h
  group DWT
    ../../User/DWT/: bsp_dwt.c bsp_dwt.h
  group IWDG
    ../../User/IWDG/: bsp_iwdg.c bsp_iwdg.h
  group Param
    ../../User/Param/: param.c param.h
